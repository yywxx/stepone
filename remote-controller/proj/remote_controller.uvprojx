# Keil uVision project remote_controller.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: remote_controller
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=111
  c include: ..\drv\inc;..\lib\inc;..\user\inc;..\user_lib\user_lib_inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user_src
    ../user/src/: main.c leds.c uarts.c
  group user_inc
    ../user/inc/: leds.h uarts.h
  group drv_src
    ../drv/src/: gpio_drv.c uart_drv.c
  group drv_inc
    ../drv/inc/: gpio_drv.h uart_drv.h
  group user_lib_src
    ../user_lib/user_lib_src/: delay.c
  group user_lib_inc
    ../user_lib/user_lib_inc/: delay.h
  group lib_src
    ../lib/src/: startup_stm32f030.s stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_i2c_cpal.c stm32f0xx_i2c_cpal_hal.c stm32f0xx_i2c_cpal_usercallback_template.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c system_stm32f0xx.c
  group lib_inc
    ../lib/inc/: stm32f0xx.h stm32f0xx_adc.h stm32f0xx_can.h stm32f0xx_cec.h stm32f0xx_comp.h stm32f0xx_conf.h stm32f0xx_crc.h stm32f0xx_crs.h stm32f0xx_dac.h stm32f0xx_dbgmcu.h stm32f0xx_dma.h stm32f0xx_exti.h stm32f0xx_flash.h stm32f0xx_gpio.h stm32f0xx_i2c.h stm32f0xx_i2c_cpal.h stm32f0xx_i2c_cpal_conf_template.h stm32f0xx_i2c_cpal_hal.h stm32f0xx_iwdg.h stm32f0xx_misc.h stm32f0xx_pwr.h stm32f0xx_rcc.h stm32f0xx_rtc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_tim.h stm32f0xx_usart.h stm32f0xx_wwdg.h system_stm32f0xx.h core_cm0.h core_cmFunc.h core_cmInstr.h stm32f0xx_i2c_cpal_conf.h
